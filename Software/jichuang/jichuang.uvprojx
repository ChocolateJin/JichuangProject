# Keil uVision project jichuang.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: CMSDK_CM0 ARM
  pack: Keil.V2M-MPS2_CMx_BSP.1.8.2
  cpu: IRAM(0x20000000,0x00400000) IROM(0x00000000,0x00400000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: code +hex
  AfterMake: fromelf -cvf .\Objects\code.axf --vhx --32x1 -o code.hex
  AfterMake: fromelf -cvf .\Objects\code.axf -o code.txt
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: .\CMSDK_CM0\Include;.\CMSIS\Include;.\drivers\Include
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x40000
  group app
    ./: main.c
  group drivers
    ./CMSDK_CM0/Source/: CMSDK_driver.c
    ./drivers/Source/: delay.c
    ./: retarget.c uart_stdout.c
    ./drivers/source/: btn_intr_driver.c
  group startup
    ./CMSDK_CM0/Source/: system_CMSDK_CM0.c
    ./CMSDK_CM0/Source/ARM/: startup_CMSDK_CM0.s
